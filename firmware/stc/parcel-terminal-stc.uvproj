# Keil uVision project parcel-terminal-stc.uvproj, settings and files
target IAP15F2K61S2 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ParcelTerminal_STC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./: STARTUP.A51
    ./source/: main.c parcel_protocol.c billing.c weight_service.c
    ./lib/: STCBSP_V3.6b.LIB
