# Keil uVision project parcel-terminal-dwin.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: ParcelTerminal_DWIN +hex
  AfterMake: .\build-dwin-set.bat
  c flags: Optimize=7 SizeSpeed=1
  c include: .\driver;.\sys;.\user
  link misc: REMOVEUNUSED
  group user
    ./user/: main.c deal.c page.c key_scan.c parcel_link.c
  group driver
    ./driver/: save_data_dgus.c crc16.c uart.c timer.c dgus_tools.c norflash.c log.c rtc.c other_tools.c dgus_8283.c canbus.c t5l_io.c
  group sys
    ./sys/: sys.c sys_isr.c
    ./: STARTUP_M5.A51
